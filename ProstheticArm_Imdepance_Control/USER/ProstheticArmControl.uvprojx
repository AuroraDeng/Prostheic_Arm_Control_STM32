# Keil uVision project ProstheticArmControl.uvprojx, settings and files
target ProstheticArmControl (6120000::V6.12::.\ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ProstheticArmControl +hex
  c flags: OneElfS=1 v6Lang=2 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\CORE;..\OBJ;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\can;..\app\CANopen\NMT;..\app\CANopen;..\app\CANopen\PDO;..\app\CANopen\SDO;..\app\usart;..\app\EPOS4;..\app\MotionControl;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F;..\app\sensor\BWT61CL;..\app\MotionControl\FuzzyPID;..\app\MotionControl\ImpedanceControl;..\app\usart\RS485;..\app\gpio;..\app\sensor\KWR46C;..\app\sensor\HWT101;..\app\timer;..\app\can;..\app\sensor\kaerman;..\app\MotionControl\Step
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_msp.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h startup_stm32f407xx.s cmsis_armclang.h cmsis_compiler.h cmsis_version.h mpu_armv7.h
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/can/: can.c
    ../app/gpio/: gpio.c
  group README
    ../: readme.txt
  group CANopen
    ../app/CANopen/NMT/: NMT_control.c
    ../app/CANopen/PDO/: pdo.c
    ../app/CANopen/SDO/: sdo.c
  group app
    ../app/usart/: usart_get.c usart_print.c usart_host_communication.c
    ../app/usart/RS485/: rs485_drv.c
    ../app/timer/: timer.c
    ../app/can/: canget.c canprint.c
    ./: resistance.c
  group Epos_MotionControl
    ../app/EPOS4/: EPOS.c
    ../app/MotionControl/: motioncontrol.cpp motor_test.cpp
    ../app/MotionControl/FuzzyPID/: FuzzyPID.c
    ../app/MotionControl/ImpedanceControl/: ImpedanceControl.c
    ../app/MotionControl/Step/: step.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group Sensor
    ../app/sensor/BWT61CL/: BWT61CL.c
    ../app/sensor/KWR46C/: KWR46C.c
    ../app/sensor/HWT101/: HWT101.c
    ../app/sensor/kaerman/: kaerman.c
